addtask build
